options:
  parameters:
    generate_options: qt_gui
    id: ptt_block
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: range1
  id: variable_qtgui_range
  parameters:
    label: kalit
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '1'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: range1
    type: float
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport time\nimport pyfirmata\nfrom pyfirmata import util\n\nclass Amp_Driver:\n    def __init__(self, arduino_do_pin):\n        arduino = pyfirmata.Arduino(self.get_com_port())\n        self.it = pyfirmata.util.Iterator(arduino)\n        self.it.start()\n\n        self.digital_output = arduino.get_pin(f\"d:{str(arduino_do_pin)}:o\")\n\n    def get_com_port(self):\n        return '/dev/ttyACM0'\n\n    def wake_up(self):\n        self.digital_output.write(0)\n\n    def shut_down(self):\n        self.digital_output.write(1)\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n    def __init__(self, arduino_pin=12):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(self, name='Arduino Driver embedded block',   # will show up in GRC\n        in_sig=[np.float32],\n        out_sig=[np.float32]\n        )\n\n        self.amp_driver = Amp_Driver(arduino_pin)\n        \n\n    def work(self, input_items, output_items):\n        if self.is_input_all_zeros(input_items):\n            self.amp_driver.shut_down()\n            output_items[0][:] = 0 # When debugging this will allow us to plug this block's output  to a time sink and see if and when the driver woke up\n        else:\n            self.amp_driver.wake_up()\n            output_items[0][:] = 1 # When debugging this will allow us to plug this block's output to a time sink and see if and when the driver shut down\n\n        return len(output_items[0])\n\n    def is_input_all_zeros(self, input_items):\n        for i in range(len(input_items[0])):\n            if input_items[0][i]!=0:\n                return False\n        return True\n\n\n"
    arduino_pin: '8'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', epy_block_1, '0']
- [epy_block_1, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
