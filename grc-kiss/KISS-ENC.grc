options:
  parameters:
    author: Or Talisman
    category: TNC
    generate_options: hb
    id: KISS_BLOCK
    output_language: python
    title: KISS Protocol
  states: {}

blocks:
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      class KISS:
      	def __init__(self):
      		self.FEND = 0xc0
      		self.FESC = 0xdb
      		self.TFEND = 0xdc
      		self.TFESC = 0xdd

      	def is_FEND(self, data_byte):
      		return data_byte == self.FEND

      	def get_encoded_start(self):
      		return (self.FESC, self.TFEND)

      	def is_FESC(self, data_byte):
      		return data_byte == self.FESC


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='KISS ENCODER',   # will show up in GRC
                  in_sig=[np.byte],
                  out_sig=[np.byte]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0]
              return len(output_items[0])
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}

connections:
- [epy_block_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', epy_block_0, '0']

metadata:
  file_format: 1
